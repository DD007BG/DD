# Keil uVision project atk_f103.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\;..\..\User;..\..\Middlewares;..\..\Middlewares\FreeRTOS\include;..\..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3;..\..\Drivers\BSP;..\..\Drivers\SYSTEM;..\..\Drivers\SYSTEM\delay;..\..\Drivers\BSP\LightSensor;..\..\Drivers\BSP\ADC;..\..\Drivers\BSP\AS312;..\..\Drivers\BSP\MQ135;..\..\Drivers\BSP\STEPPER;..\..\Drivers\BSP\PWM;..\..\Drivers\BSP\ESP8266;..\..\Drivers\SYSTEM\usart2;..\..\Drivers\BSP\ATK_MW8266D;..\..\Drivers\BSP\MALLOC;..\..\Drivers\BSP\MQTT;..\..\Drivers\BSP\aliyun_net
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c stm32f1xx_it.c freertos_tasks.c demo.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/TIMER/: btim.c
    ../../Drivers/BSP/DHT11/: DHT11.c
    ../../Drivers/BSP/LightSensor/: LightSensor.c
    ../../Drivers/BSP/ADC/: adc.c
    ../../Drivers/BSP/AS312/: as312.c
    ../../Drivers/BSP/MQ135/: MQ135.c
    ../../Drivers/BSP/STEPPER/: Stepper.c
    ../../Drivers/BSP/PWM/: pwm.c
    ../../Drivers/BSP/ATK_MW8266D/: atk_mw8266d.c atk_mw8266d_uart.c
    ../../Drivers/BSP/MQTT/: MqttKit.c
    ../../Drivers/BSP/aliyun_net/: aliyun_net.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/FreeRTOS_CORE
    ../../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group Readme
    ../../: readme.txt
